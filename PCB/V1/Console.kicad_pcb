# Repository Aliasmk/EMRSNxEOS

File README.md:

# EMRSNxEOS

Project built in VSCode PlatformIO.

The system targets the ESP32, and uses the [OSC Library](https://github.com/CNMAT/OSC) and the [u8g2 graphics library](https://github.com/olikraus/u8g2).

## KiCad design PCB/V1/Console.kicad_pcb

Parts:
H1, H2, H3, H4, H5, H6, H7, H8: MountingHole; MountingHole_2.7mm_M2.5
H9: MountingHole; Ghost
H10: MountingHole; OSHW-Logo_5.7x6mm_SilkScreen
H11: MountingHole; KiCad-Logo2_5mm_SilkScreen

Parts:
C1: 0.1uF; C_0603_1608Metric; MPN UMK107B7104KA-T; Digikey 587-1243-1-ND
C2, C5: 1uF; C_0603_1608Metric; MPN CL10A105KA8NNNC; Digikey 1276-1102-1-ND
C3, C4: 20p; C_0402_1005Metric; MPN 04023U200JAT2A; Digikey 478-11758-1-ND
D1: LED_Green; LED_0603_1608Metric; MPN LTST-C191KGKT; Digikey 160-1446-1-ND
D2, D3, D4, D5, D6, D7: LED_CoolWhite; Digikey 1616-GBL7IW60D-CW-ND
J1: Programming Header; PinHeader_2x03_P2.54mm_Vertical; MPN PH2-06-UA; Digikey 2057-PH2-06-UA-ND
J2: UART; PinHeader_1x02_P2.54mm_Vertical
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R1, R3, R4, R5, R6, R7, R8: 270R; R_0402_1005Metric; MPN RC0402JR-07270RL; Digikey 311-270JRCT-ND
R2, R34, R35, R36, R37, R38, R39: 10k; R_0402_1005Metric; MPN RMCF0402FT10K0; Digikey RMCF0402FT10K0CT-ND
RV1, RV2, RV3: R_POT; SliderHeader; MPN PTA4553-2210CIB103; Digikey PTA4553-2210CIB103-ND
SW1, SW2, SW3, SW4, SW5, SW6: SW_Push_LED; SW_Cherry_MX_Single_LED; MPN MX1A-11NW; Digikey CH160-ND
TP1: TestPoint; TestPoint_Pad_1.5x1.5mm
U1: ATmega328P-PU; TQFP-32_7x7mm_P0.8mm; MPN ATMEGA328PB-AU; Digikey ATMEGA328PB-AU-ND
U2: MCP23017_SO; SOIC-28W_7.5x17.9mm_P1.27mm; MPN MCP23017T-E/SO; Digikey MCP23017T-E/SOCT-ND
Y1: 16MHz; ECS-120-12-36-AGN; Digikey XC2622CT-ND

Connections:
+3V3: C2.1, C5.2, J1.2, R2.1, R34.1, R35.1, R36.1, R37.1, R38.1, R39.1, RV1.1, RV2.1, RV3.1, U1.7 (VCC), U1.20 (AVCC), U2.9 (VDD), U2.18 (~RESET~); also elsewhere on the board
/Core/BTN_INT: U2.20 (INTA); also elsewhere on the board
/Core/SCL: U1.28 (PC5), U2.12 (SCK); also elsewhere on the board
/Core/SDA: U1.27 (PC4), U2.13 (SDA); also elsewhere on the board
/Peripherals/CIDO: J1.1, U1.17 (PB3)
/Peripherals/CODI: J1.4, U1.18 (PB4)
/Peripherals/ENC1_A: U1.13 (PD7); also elsewhere on the board
/Peripherals/ENC1_B: U1.12 (PD6); also elsewhere on the board
/Peripherals/ENC1_SW: U2.4 (GPB3); also elsewhere on the board
/Peripherals/ENC2_A: U1.11 (PD5); also elsewhere on the board
/Peripherals/ENC2_B: U1.6 (PD4); also elsewhere on the board
/Peripherals/ENC2_SW: U2.3 (GPB2); also elsewhere on the board
/Peripherals/ENC3_A: U1.5 (PD3); also elsewhere on the board
/Peripherals/ENC3_B: U1.4 (PD2); also elsewhere on the board
/Peripherals/ENC3_SW: U2.2 (GPB1); also elsewhere on the board
/Peripherals/ENC4_A: U1.3 (PD1); also elsewhere on the board
/Peripherals/ENC4_B: U1.2 (PD0); also elsewhere on the board
/Peripherals/ENC4_SW: U2.1 (GPB0); also elsewhere on the board
/Peripherals/LED: R1.1, U1.16 (PB2)
/Peripherals/RXD: J2.2, U1.14 (PB0)
/Peripherals/SCLK: J1.3, U1.19 (PB5)
/Peripherals/SLD1: RV1.2, U1.25 (PC2)
/Peripherals/SLD2: RV2.2, U1.24 (PC1)
/Peripherals/SLD3: RV3.2, U1.23 (PC0)
/Peripherals/SPARE: TP1.1, U1.26 (PC3)
/Peripherals/SW_1: R34.2, SW1.2, U2.26 (GPA5)
/Peripherals/SW_2: R35.2, SW2.2, U2.25 (GPA4)
/Peripherals/SW_3: R36.2, SW3.2, U2.24 (GPA3)
/Peripherals/SW_4: R37.2, SW4.2, U2.21 (GPA0)
/Peripherals/SW_5: R38.2, SW5.2, U2.22 (GPA1)
/Peripherals/SW_6: R39.2, SW6.2, U2.23 (GPA2)
/Peripherals/TXD: J2.1, U1.15 (PB1)
/Peripherals/XTAL1: C3.2, U1.9 (XTAL1/PB6), Y1.1
/Peripherals/XTAL2: C4.2, U1.10 (XTAL2/PB7), Y1.3
/Peripherals/~RESET: J1.5, JP1.1 (A), R2.2, U1.1 (~RESET~/PC6)
LED_Power: R3.1, R4.1, R5.1, R6.1, R7.1, R8.1; also elsewhere on the board
unnamed: C1.1, U1.21 (AREF)
unnamed: D1.2 (A), R1.2
unnamed: R3.2, SW1.4 (A)
unnamed: R4.2, SW2.4 (A)
unnamed: R5.2, SW3.4 (A)
unnamed: R6.2, SW4.4 (A)
unnamed: R7.2, SW5.4 (A)
unnamed: R8.2, SW6.4 (A)

Notes on the sheet:
INT Pins Mirrored IOCON:MIRROR = 1
Faders x3
IO Expander for Encoder and Keypad Switches
Keypad Switches x6
Encoders x4
ATMega Aux Processor
Switch LEDs for BOM
All encoders on the same port to facilitate fast channel reading upon Pin Change Interrupt (PCINT)
Talks directly to Core Processor, not Aux Processor

Parts:
C18, C19: 20p; C_0402_1005Metric; MPN 04023U200JAT2A; Digikey 478-11758-1-ND
C20, C22, C23, C26, C27, C29, C32, C33: 0.1uF; C_0603_1608Metric; MPN CC0603KRX5R9BB104; Digikey 311-4046-1-ND
C21, C24, C25, C30, C31: 120uF; CP_Radial_D6.3mm_P2.50mm; MPN 865080545012; Digikey 732-8511-1-ND
C28: 4.7uF; C_1206_3216Metric; MPN CL31B475KAHNNNE; Digikey 1276-1055-1-ND
D8: SP0503BAHT; SOT-143; MPN SP0503BAHTG; Digikey F2715CT-ND
D9: DT1240A-08LP3810; UDFN-9_1.0x3.8mm_P0.5mm
D10, D11: LED; LED_0603_1608Metric; MPN LTST-C191KFKT; Digikey 160-1445-1-ND
FB1, FB2, FB3, FB4, FB5, FB6, FB7, FB8, FB9, FB10: Ferrite_Bead_Small; L_0805_2012Metric; MPN BLM21PG221SN1D; Digikey 490-1054-1-ND
J3: USB_B; USB_B_OST_USB-B1HSxx_Horizontal; MPN USB-B1HSW6; Digikey ED2982-ND
J4: USB_A; USB_A_Molex_67643_Horizontal; MPN USB-A-S-VT; Digikey 2057-USB-A-S-VT-ND
J5, J6: USB_A; PinHeader_1x05_P1.27mm_Vertical; MPN USB-A-S-VT; Digikey 2057-USB-A-S-VT-ND
J7: USB_A; USB_A_Molex_67643_Horizontal; MPN USB-A-S-RA; Digikey 2057-USB-A-S-RA-ND
R9, R12, R13, R17, R20: 10k; R_0402_1005Metric; MPN RMCF0402FT10K0; Digikey RMCF0402FT10K0CT-ND
R10: 100k; R_0402_1005Metric; MPN AC0402JR-07100KL; Digikey YAG3515CT-ND
R11: 650R; R_0402_1005Metric; MPN ERJ-2RKF6493X; Digikey P649KLCT-ND
R14: DNP; R_0402_1005Metric
R15: 22.1k; R_0402_1005Metric; MPN AC0402FR-0722K1L; Digikey YAG3457CT-ND
R16: 47.5k; R_0402_1005Metric; MPN RMCF0402FT47K5; Digikey RMCF0402FT47K5CT-ND
R18, R19: 270R; R_0402_1005Metric; MPN RC0402JR-07270RL; Digikey 311-270JRCT-ND
R64, R65, R66, R67: 10k; R_0402_1005Metric
TP2, TP3: TestPoint; TestPoint_Pad_1.5x1.5mm
U3: CY7C65632-28LTXC; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm; MPN CY7C65632-28LTXC; Digikey CY7C65632-28LTXC-ND
U4: 24LC02; SOIC-8_3.9x4.9mm_P1.27mm; MPN 24LC02BT/SNCT-ND; Digikey 24LC02BT/SN
U5: MIC2027-2BM; SOIC-16_3.9x9.9mm_P1.27mm; MPN MIC2027-1YM; Digikey 576-2138-ND
U6: CP2102N-A02-GQFN20; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm; MPN CP2102N-A02; Digikey 336-5885-ND
Y2: 12MHz; ECS-120-12-36-AGN; Digikey XC2710CT-ND

Connections:
+3V3: C20.2, C28.2, C29.2, R9.1, R12.2, R13.2, R14.1, R17.2, R64.1, R65.1, R66.1, R67.1, U3.5 (VCC_A), U3.9 (VCC_A), U3.14 (VCC_A), U3.21 (VCC_D), U3.28 (VREG), U4.8 (VCC), U6.6 (VDD), U6.7 (VREGIN); also elsewhere on the board
/Core/RXD0: U6.18 (TXD); also elsewhere on the board
/Core/SUSPEND_SENSE: R20.1, U6.14 (SUSPEND); also elsewhere on the board
/Power/SELF_POWER: U3.22 (SELFPWR); also elsewhere on the board
/USB Hub and Serial Converter/D1N: U3.3 (DD-1), U6.5 (D-)
/USB Hub and Serial Converter/D1P: U3.4 (DD+1), U6.4 (D+)
/USB Hub and Serial Converter/D2N: J5.2 (D-), U3.6 (DD-2)
/USB Hub and Serial Converter/D2P: J5.3 (D+), U3.7 (DD+2)
/USB Hub and Serial Converter/D3N: D9.9 (K8), J6.2 (D-), U3.12 (DD-3)
/USB Hub and Serial Converter/D3P: D9.8 (K7), J6.3 (D+), U3.13 (DD+3)
/USB Hub and Serial Converter/D4N: D9.7 (K6), J7.2 (D-), U3.15 (DD-4)
/USB Hub and Serial Converter/D4P: D9.6 (K5), J7.3 (D+), U3.16 (DD+4)
/USB Hub and Serial Converter/DIN_N: D8.3 (K), J3.2 (D-), U3.1 (D-)
/USB Hub and Serial Converter/DIN_P: D8.2 (K), J3.3 (D+), U3.2 (D+)
/USB Hub and Serial Converter/EEPROM_SCL: R13.1, TP3.1, U3.18 (TEST/I2C_SCL), U4.6 (SCL)
/USB Hub and Serial Converter/EEPROM_SDA: R12.1, TP2.1, U3.26 (~PWR~/I2C_SDA), U4.5 (SDA)
/USB Hub and Serial Converter/RXD: U6.17 (RXD); also elsewhere on the board
/USB Hub and Serial Converter/VBUS_A: C25.1, FB5.2, U5.3 (OUTA)
/USB Hub and Serial Converter/VBUS_B: C24.1, FB3.2, U5.14 (OUTB)
/USB Hub and Serial Converter/VBUS_C: C30.1, FB7.2, U5.6 (OUTC)
/USB Hub and Serial Converter/VBUS_D: C31.1, FB9.2, U5.11 (OUTD)
/USB Hub and Serial Converter/XIN: C18.1, U3.10 (XIN), Y2.1
/USB Hub and Serial Converter/XOUT: C19.1, U3.11 (XOUT), Y2.3
/USB Hub and Serial Converter/~OVR1: R64.2, U3.25 (~OVR1), U5.1 (FLGA)
/USB Hub and Serial Converter/~OVR2: R65.2, U3.24 (~OVR2), U5.16 (FLGB)
/USB Hub and Serial Converter/~OVR3: R66.2, U3.20 (~OVR3), U5.8 (FLGC)
/USB Hub and Serial Converter/~OVR4: R67.2, U3.19 (~OVR4), U5.9 (FLGD)
unnamed: C21.1, FB1.2, J3.1 (VBUS)
unnamed: C21.2, FB2.2, J3.4 (GND)
unnamed: C26.1, FB3.1, J5.1 (VBUS)
unnamed: C26.2, FB4.1, J5.4 (GND), J5.5 (Shield)
unnamed: C27.1, FB5.1, J4.1 (VBUS)
unnamed: C27.2, FB6.1, J4.4 (GND), J4.5 (Shield)
unnamed: C32.1, FB7.1, J6.1 (VBUS)
unnamed: C32.2, FB8.1, J6.4 (GND), J6.5 (Shield)
unnamed: C33.1, FB9.1, J7.1 (VBUS)
unnamed: C33.2, FB10.1, J7.4 (GND), J7.5 (Shield)
unnamed: D10.2 (A), R19.2
unnamed: D11.2 (A), R18.2
unnamed: R9.2, U3.17 (~RESET)
unnamed: R10.2, U3.23 (GANG)
unnamed: R11.2, U3.8 (RREF)
unnamed: R17.1, U6.9 (~RST)
unnamed: R18.1, U6.20 (GPIO2/TXT)
unnamed: R19.1, U6.19 (GPIO3/RXT)

Notes on the sheet:
500mA per channel max
Input USB Connector
USB Controller, Bus Voltage Controller
USB VID/PID EEPROM
Output USB Connectors
USB to Serial Converter (To ESP32 UART)
To Rear USB (Power + Data)
To Panel USB
To Rear USB (Power Only)
To Keyboard (Internal)
Hardwired Connection (Internal)
ESD Protection

Parts:
C34: 0.1uF; C_0402_1005Metric; MPN UMK107B7104KA-T; Digikey 1276-1043-1-ND
C35, C36, C38: 4.7uF; C_0805_2012Metric; MPN CL31B475KAHNNNE; Digikey 1276-1244-1-ND
C37: 22uF; C_0805_2012Metric; MPN CL21A226KQCLRNC; Digikey 1276-2909-1-ND
D12: DDZ5V6BSF-7; D_SOD-323F; Digikey DDZ5V6BSF-7DICT-ND
D13: LED_Red; LED_0603_1608Metric; MPN LTST-C191KRKT; Digikey 160-1447-1-ND
D14: S4SRP; D_SMB_Modified; Digikey S4SCT-ND
D15: LED_Green; LED_0603_1608Metric; MPN LTST-C191KGKT; Digikey 160-1183-1-ND
D16: LED_Blue; LED_0603_1608Metric; MPN LTST-C191TBKT; Digikey 160-1647-1-ND
J8: Barrel_Jack_Switch; BarrelJack_CUI_PJ-102AH_Horizontal; MPN PJ-102AH; Digikey CP-102AH-ND
Q1, Q3: CPH3356-TL-W; SOT-23; Digikey CPH3356-TL-WOSCT-ND
Q2: MMBT3904; SOT-23; Digikey 1727-4044-1-ND
R2: 1k; R_0402_1005Metric; MPN AC0402JR-07100KL; Digikey RMCF0402FT100KCT-ND
R15: 10k; R_0402_1005Metric; MPN AC0402JR-07100KL; Digikey RMCF0402FT100KCT-ND
R21: 510k; R_0402_1005Metric; MPN RMCF0402FT510K; Digikey RMCF0402FT510KCT-ND
R22: 1k; R_0402_1005Metric; MPN RMCF0402FT1K00; Digikey RMCF0402FT1K00CT-ND
R23: 4.7k; R_0402_1005Metric; MPN RMCF0402FT4K70; Digikey RMCF0402FT4K70CT-ND
R24, R25, R26: 270R; R_0402_1005Metric; MPN RC0402JR-07270RL; Digikey 311-270JRCT-ND
U7: DMP1005UFDF; Diodes_UDFN2020-6_Type-F; Digikey DMP1005UFDF-7DICT-ND
U8: AP2114HA-3.3TRG1; SOT-223-3_TabPin2; MPN AP2114HA-3.3TRG1DICT-ND; Digikey AP2114HA-3.3TRG1DICT-ND

Connections:
+3V3: C38.1, R2.1, R24.2, U8.3 (VOUT); also elsewhere on the board
/Peripherals/~RESET: R2.2; also elsewhere on the board
/Power/SELF_POWER: J8.3, R21.2, R23.1; also elsewhere on the board
/Power/VCC_IN: C34.1, D12.1 (K), D14.2 (A), J8.1, R21.1, U7.4 (S), U7.8
LED_Power: Q3.3 (D); also elsewhere on the board
unnamed: D12.2 (A), D14.3 (G), R22.1
unnamed: D13.2 (A), R24.1
unnamed: D15.2 (A), R25.1
unnamed: D16.2 (A), R26.1
unnamed: Q1.1 (G), R23.2
unnamed 109: Q2.1; also elsewhere on the board

Notes on the sheet:
Power Input: 5V, 1.5A DC
Allows the system to accept additional power from the power jack. USB Only: VCC_IN = SELF_POWER = 0V; MOSFET ON, VBUS ≡ +5V DC In: VCC_IN = 5V, SELF_POWER = 5V (switch open); MOSFET OFF, VBUS floating
Input Voltage and Protection - Protects against overvoltage by activating the SCR diode above the conduction voltage of the zener diode - Protects against reverse voltage by closing the MOSFET if the Gate (Ground) is higher than pin 4 (VCC_IN), which can only happen if the connection is reversed
PWM LED Driver - Select between 5V and 3V3 diode voltage (useful for white LEDs which have high forward voltage) - When the gate of the MOSFET (pin 1) is equal to the source (pin 2), current is not allowed to flow to the LEDs - When the gate is lower than the source, current IS allowed to flow - To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
3V3 Regulator Generates 3V3 from the 5V input coming from the power jack or USB
Power Status LEDs

Parts:
C39: 22uF; C_0805_2012Metric; MPN CL21A226KQCLRNC; Digikey 1276-6687-1-ND
C40, C41: 0.1uF; C_0603_1608Metric; MPN UMK107B7104KA-T; Digikey 587-1243-1-ND
C42: 1uF; C_0603_1608Metric; MPN CL10A105KA8NNNC; Digikey 1276-1102-1-ND
D17: LED_Green; LED_0603_1608Metric; MPN LTST-C191KGKT; Digikey 160-1446-1-ND
J9: Programming Header; PinSocket_1x04_P1.27mm_Vertical; MPN PH1-04-UA; Digikey 2057-PH1-04-UA-ND
R31, R68, R69: 10k; R_0402_1005Metric; MPN RMCF0402FT10K0; Digikey RMCF0402FT10K0CT-ND
R33: 270R; R_0402_1005Metric; MPN RC0402JR-07270RL; Digikey 311-270JRCT-ND
SW11, SW12: SW_Push; PTS636 SK25F SMTR LFS; MPN PTS636 SK25F SMTR LFS; Digikey CKN12330-1-ND
U9: ESP32-WROOM-32; MPN ESP32-WROOM-32U (16MB); Digikey 1904-1028-1-ND
U10: NHD-3.12-25664UCW2; PinSocket_1x20_P2.54mm_Vertical; MPN NHD-3.12-25664UCW2; Digikey NHD-3.12-25664UCW2-ND

Connections:
+3V3: C39.1, C42.1, J9.1, R31.1, R68.1, R69.1, U9.2 (VDD), U10.2 (VDD); also elsewhere on the board
/Core/BOOT: C41.2, SW12.1, U9.25 (IO0)
/Core/BTN_INT: U9.31 (IO19); also elsewhere on the board
/Core/EN: C40.1, R31.2, SW11.2, U9.3 (EN)
/Core/LED: R33.1, U9.30 (IO18)
/Core/LED_PWM: U9.29 (IO5); also elsewhere on the board
/Core/OLED_BS1: U9.27 (IO16), U10.19 (BS1)
/Core/OLED_BS2: U9.28 (IO17), U10.20 (BS2)
/Core/OLED_D0: U9.9 (IO33), U10.7 (DB0/SCLK)
/Core/OLED_D1: U9.10 (IO25), U10.8 (DB1/SDIN)
/Core/OLED_D2: U9.11 (IO26), U10.9 (DB2/NC)
/Core/OLED_D3: U9.12 (IO27), U10.10 (DB3/VSS)
/Core/OLED_D4: U9.13 (IO14), U10.11 (DB4/VSS)
/Core/OLED_D5: U9.14 (IO12), U10.12 (DB5/VSS)
/Core/OLED_D6: U9.16 (IO13), U10.13 (DB6/VSS)
/Core/OLED_D7: U9.23 (IO15), U10.14 (DB7/VSS)
/Core/OLED_DC: U9.6 (IO34), U10.4 (D/C)
/Core/OLED_EN: U9.8 (IO32), U10.6 (EN)
/Core/OLED_RW: U9.7 (IO35), U10.5 (R/W)
/Core/OLED_~CS: U9.26 (IO4), U10.17 (~CS)
/Core/OLED_~RESET: U9.24 (IO2), U10.16 (~RESET)
/Core/RXD0: J9.3, U9.34 (RXD0/IO3); also elsewhere on the board
/Core/SCL: R69.2, U9.37 (IO23); also elsewhere on the board
/Core/SDA: R68.2, U9.36 (IO22); also elsewhere on the board
/Core/SUSPEND_SENSE: U9.33 (IO21); also elsewhere on the board
/USB Hub and Serial Converter/RXD: J9.2, U9.35 (TXD0/IO1); also elsewhere on the board
unnamed: D17.2 (A), R33.2

Notes on the sheet:
OLED Display
ESP32 Main Processor

Parts:
C6, C7, C8: 10n; C_0402_1005Metric; MPN CC0402JRX7R8BB103; Digikey 311-1677-1-ND
R40, R41, R42, R43, R44, R45: 10k; R_0402_1005Metric; MPN RMCF0402FT10K0; Digikey RMCF0402FT10K0CT-ND
SW7: Rotary_Encoder_Switch; PEC12RHeader; MPN PEC11R-4220F-S0012; Digikey PEC11R-4220F-S0012-ND

Connections:
+3V3: R42.2, R43.2, R45.1; also elsewhere on the board
/Peripherals/ENC2_A: C7.1, R40.2; also elsewhere on the board
/Peripherals/ENC2_B: C6.1, R41.2; also elsewhere on the board
/Peripherals/ENC2_SW: C8.1, R44.2, R45.2; also elsewhere on the board
unnamed: R40.1, R43.1, SW7.A
unnamed: R41.1, R42.1, SW7.B
unnamed: R44.1, SW7.S1

Parts of its further copies:
C9, C10, C11, C12, C13, C14, C15, C16, C17: 10n; C_0402_1005Metric; MPN CC0402JRX7R8BB103; Digikey 311-1677-1-ND
SW8, SW9, SW10: Rotary_Encoder_Switch; PEC12RHeader; MPN PEC11R-4220F-S0012; Digikey PEC11R-4220F-S0012-ND

Connections of its further copies:
/Peripherals/ENC1_A: C16.1; also elsewhere on the board
/Peripherals/ENC1_B: C15.1; also elsewhere on the board
/Peripherals/ENC1_SW: C17.1; also elsewhere on the board
/Peripherals/ENC3_A: C10.1; also elsewhere on the board
/Peripherals/ENC3_B: C9.1; also elsewhere on the board
/Peripherals/ENC3_SW: C11.1; also elsewhere on the board
/Peripherals/ENC4_A: C13.1; also elsewhere on the board
/Peripherals/ENC4_B: C12.1; also elsewhere on the board
/Peripherals/ENC4_SW: C14.1; also elsewhere on the board
unnamed 125: SW8.A; also elsewhere on the board
unnamed 126: SW8.B; also elsewhere on the board
unnamed 127: SW8.S1; also elsewhere on the board
unnamed 128: SW9.A; also elsewhere on the board
unnamed 129: SW9.B; also elsewhere on the board
unnamed 130: SW9.S1; also elsewhere on the board
unnamed 131: SW10.A; also elsewhere on the board
unnamed 132: SW10.B; also elsewhere on the board
unnamed 133: SW10.S1; also elsewhere on the board

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
Board: 2 copper layers, 168.0 x 72.5 mm, 186 parts (0 on the bottom side), 134 nets.

Other parts of the board:
R27: 0R; R_0402_1005Metric
R28: DNP; R_0402_1005Metric
R29, R30: 1k; R_0402_1005Metric
R32, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63: 10K; R_0402_1005Metric

Their connections:
+3V3: R28.2, R48.2, R49.2, R51.1, R54.2, R55.2, R57.1, R60.2, R61.2, R63.1; also elsewhere on the board
/Core/LED_PWM: R29.2; also elsewhere on the board
/Peripherals/ENC1_A: R58.2; also elsewhere on the board
/Peripherals/ENC1_B: R59.2; also elsewhere on the board
/Peripherals/ENC1_SW: R62.2, R63.2; also elsewhere on the board
/Peripherals/ENC3_A: R46.2; also elsewhere on the board
/Peripherals/ENC3_B: R47.2; also elsewhere on the board
/Peripherals/ENC3_SW: R50.2, R51.2; also elsewhere on the board
/Peripherals/ENC4_A: R52.2; also elsewhere on the board
/Peripherals/ENC4_B: R53.2; also elsewhere on the board
/Peripherals/ENC4_SW: R56.2, R57.2; also elsewhere on the board
unnamed 109: R29.1; also elsewhere on the board
unnamed 125: R46.1, R49.1; also elsewhere on the board
unnamed 126: R47.1, R48.1; also elsewhere on the board
unnamed 127: R50.1; also elsewhere on the board
unnamed 128: R52.1, R55.1; also elsewhere on the board
unnamed 129: R53.1, R54.1; also elsewhere on the board
unnamed 130: R56.1; also elsewhere on the board
unnamed 131: R58.1, R61.1; also elsewhere on the board
unnamed 132: R59.1, R60.1; also elsewhere on the board
unnamed 133: R62.1; also elsewhere on the board

## Code that names these connections

File Code/ConsoleCore/include/pins.hpp:

#ifndef PINS_HPP
#define PINS_HPP

#define UNDEFINED_PIN 99

#define PIN_OLED_CS     15
#define PIN_ESP_TXD     1
#define PIN_OLED_RESET  2
#define PIN_ESP_RXD     3
#define PIN_LED_PWM     4
#define PIN_BTN_INT     5
#define PIN_LED         12
#define PIN_SPARE_1     13
#define PIN_SPARE_2     14
#define PIN_SPARE_3     15
#define PIN_ENC4_A      16
#define PIN_ENC4_B      17
#define PIN_VSPI_SCLK   18
#define PIN_SPARE_4     19
#define PIN_SDA         21
#define PIN_SCL         22
#define PIN_VSPI_MOSI   23
#define PIN_ENC2_B      25
#define PIN_ENC3_B      26
#define PIN_ENC3_A      27
#define PIN_SLD3        32
#define PIN_ENC2_A      33
#define PIN_SLD1        34
#define PIN_SLD2        35
#define PIN_ENC1_A      36
#define PIN_ENC1_B      39

#endif

## Commit log

2020-05-24 Fixed crash when using large number of params (serial buff overrun)
2020-06-17 Integrated io/button class from HapticEye
2020-06-25 Add Pages and Group Selection
2020-06-27 Prelim Encoder Code
2020-06-28 Improve display performance and interaction w IO
2020-06-29 Add Wheel OSC commands
2020-07-02 Improved Encoder detection, coarse/fine, active parameter switch
2020-07-08 Various Improvements
2020-09-25 Code refactor; Electrical Schematic; Add ATMega WS
2020-09-25 Schematic, Code Refactor, 328P workspace
2020-09-25 Refactor to change "IO" class to "Button"
2020-11-15 WIP PCB changes
2020-11-15 PCB "Complete", still needs checking etc
2021-01-13 PCB Version 1: As Sent to Fab
2021-02-07 Fix display to work with new hardware. Implement io expander driver for using on board buttons
2021-03-21 WIP schematic work, ready to route board V2
2021-03-26 PCB Sent
2021-05-02 Code working with V2 board, V3 PCB created
2021-05-03 Re-added encoder code, working well
2021-07-24 Keys now change page if clicked multiple times, Wi-Fi Ap enabled, fader type fix
2022-01-08 Add QMK files
2022-11-09 Create LICENSE
